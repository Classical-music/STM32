# Keil uVision project c8t6Car.uvprojx, settings and files
target c8t6car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6Car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\src\startup;.\src\drivers;.\src\bsp;.\src\user;.\src\test
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./src/startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group bsp
    ./src/bsp/led/: bsp_led.c
    ./src/bsp/tick/: bsp_tick.c
    ./src/bsp/seg/: bsp_seg.c
    ./src/bsp/beep/: bsp_beep.c
    ./src/bsp/: board.c
  group test
    ./src/test/seg/: test_seg.c
    ./src/test/beep/: test_beep.c
  group user
    ./src/user/: main.c
