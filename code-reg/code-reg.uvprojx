# Keil uVision project code-reg.uvprojx, settings and files
target target-reg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: code-reg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE
  c misc: --gnu --diag_suppress=68,111,188,546
  c include: .\src\startup;.\src\drivers;.\src\bsp;.\src\middleware;.\src\middleware\utils;.\src\user;.\src\user\led;.\src\middleware\freeRTOS;.\src\middleware\freeRTOS\include;.\src\middleware\freeRTOS\portable\RVDS\ARM_CM3;.\src\tasks;.\src\middleware\lvgl;.\src\middleware\lvgl\src;.\src\middleware\lvgl\port\stm32;.\src\middleware\lvgl\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group startup
    ./src/startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group drivers
    ./src/drivers/usart/: usart.c
    ./src/drivers/wwdg/: wwdg.c
    ./src/drivers/tim/: tim.c
    ./src/drivers/dma/: dma.c
    ./src/drivers/i2c/: i2c_soft.c i2c_hard.c i2c.c
    ./src/drivers/spi/: spi.c
    ./src/drivers/fsmc/: fsmc.c
  group bsp
    ./src/bsp/key/: key.c
    ./src/bsp/led/: led.c
    ./src/bsp/beep/: beep.c
    ./src/bsp/tpad/: tpad.c
    ./src/bsp/: board.c
    ./src/bsp/eeprom/: eeprom.c bsp_24c02.c
    ./src/bsp/flash/: flash.c m25q128.c
    ./src/bsp/lcd/: lcd.c lcd_nt35510.c
    ./src/bsp/touch/: bsp_touch.c gt911.c
    ./src/bsp/sram/: bsp_sram.c
  group middleware\utils
    ./src/middleware/utils/: cqueue.c
  group user
    ./src/user/: main.c
  group user/test
    ./src/user/test/: eeprom_test.c test.c flash_test.c lcd_test.c sram_test.c
  group middleware/freeRTOS
    ./src/middleware/freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./src/middleware/freeRTOS/portable/MemMang/: heap_5.c heap_5_realloc.c
    ./src/middleware/freeRTOS/portable/RVDS/ARM_CM3/: port.c
  group tasks
    ./src/tasks/beep/: task_beep.c
    ./src/tasks/led/: task_led.c
    ./src/tasks/app/: task_app.c
    ./src/tasks/key/: task_key.c
    ./src/tasks/console/: task_console.c
    ./src/tasks/cmd/: task_cmd.c cmd.c
    ./src/tasks/gui/: task_gui.c
    ./src/tasks/touch/: task_touch.c
    ./src/tasks/gui/views/: views.c
    ./src/tasks/gui/common/: router.c system_bar.c dock.c
    ./src/tasks/gui/pages/: home.c led_beep.c
    ./src/tasks/gui/components/: ui_button.c
  group lvgl
    ./src/middleware/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./src/middleware/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./src/middleware/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./src/middleware/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./src/middleware/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./src/middleware/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./src/middleware/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./src/middleware/lvgl/port/stm32/: lv_port_disp.c lv_port_indev.c
    ./src/middleware/lvgl/examples/porting/: lv_port_fs_template.c
    ./src/middleware/lvgl/src/extra/: lv_extra.c
    ./src/middleware/lvgl/src/extra/themes/default/: lv_theme_default.c
